# Keil uVision project RTC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: RTC +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\LCD;..\USER\LED;..\USER\RTC;..\USER\KEY;..\USER\cJSON;..\USER\usart1;..\HanZi;..\USER\MALLOC;..\USER\W25QXX;..\USER\SPI;..\USER\TF_SDIO;..\FATFS;..\FATFS\src;..\FATFS\src\option;..\USER\24C02
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group USER
    ../USER/LCD/: lcd.c
    ../USER/LED/: led.c
    ../USER/KEY/: key.c
    ../USER/cJSON/: cJSON.c
    ../USER/usart1/: usart1.c
    ../USER/24C02/: 24c02.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_usart.c stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_syscfg.c
  group Common
    ../Common/: common.c
